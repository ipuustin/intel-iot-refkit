REQUIRED_DISTRO_FEATURES = "x11"
inherit distro_features_check
